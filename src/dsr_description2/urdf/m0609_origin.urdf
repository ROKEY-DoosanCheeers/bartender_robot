Commit message: [UPDATE] Shaker pour for modeling

File: src/dsr_description2/urdf/m0609_origin.urdf (robot description, URDF)
Before this commit: robot m0609, 9 links, 8 joints
Links:
- removed link tool0
Joints:
- removed joint joint_6-tool0
